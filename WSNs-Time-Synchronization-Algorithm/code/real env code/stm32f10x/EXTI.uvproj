# Keil uVision project EXTI.uvproj, settings and files
target EXTI (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: release +hex
  c flags: Optim=4 OneElfS=1
  c include: .\
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./: STM32F10x.s
  group Interrupts
    ./: stm32f10x_it.c
  group Library
    D:/开发板使用/test/common/: STM32F10xR.lib
  group Source
    ./: main.c
  group Documentation
    ./: readme.txt
