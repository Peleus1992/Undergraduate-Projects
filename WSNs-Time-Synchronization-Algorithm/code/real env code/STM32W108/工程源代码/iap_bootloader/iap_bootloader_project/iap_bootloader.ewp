# IAR project iap_bootloader.ewp, settings and files
configuration MB851 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32W108 ST STM32W108
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\HAL\MICRO\CORTEXM3\STM32W108
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: iap_bootloader.s37
  ILINK.IlinkOutputFile: iap_bootloader.out
  ILINK.IlinkIcfFile: ..\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group iap_bootloader_library
    ../iap_bootloader_library/: iap_bootloader_library.a
  group iap_bootloader_user_functions
    ../: bl_user.c
