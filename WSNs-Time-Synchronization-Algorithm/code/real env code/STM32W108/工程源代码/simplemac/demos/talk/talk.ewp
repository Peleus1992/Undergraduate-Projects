# IAR project talk.ewp, settings and files
configuration MB851 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32W108 ST STM32W108
  ICCARM.CCDefines: BOARD_MB851; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; PHY_STM32W108XX; DISABLE_WATCHDOG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\simplemac\include; ..\..\..; ..\..\..\hal; ..\..\..\HAL\MICRO\CORTEXM3\STM32W108; ..\..\..\simplemac; ..\..\..\shared
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: talk.s37
  ILINK.IlinkOutputFile: talk.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/stm32w108/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB851-btl (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: talk-btl.s37
  ILINK.IlinkOutputFile: talk-btl.out
  ILINK.IlinkConfigDefines: ST_BTL=1
  group hal
    ../../../hal/micro/cortexm3/: adc.c clocks.c context-switch.s79 cstartup_M.s flash.c led.c mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c spmr.s79 uart.c
    ../../../hal/micro/cortexm3/stm32w108/: low_level_init.c
  group simplemac_library
    ../../library/: simplemac-library.a
  group talk_application
    ./: talk.c
