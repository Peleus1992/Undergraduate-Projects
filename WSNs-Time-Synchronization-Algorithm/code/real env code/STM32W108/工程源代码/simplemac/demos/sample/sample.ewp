# IAR project sample.ewp, settings and files
configuration MB851_SUN (ARM, debug)
  General.OGChipSelectEditMenu: STM32W108 ST STM32W108
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_MB851; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; PHY_STM32W108XX; DISABLE_WATCHDOG; SUN_ROLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\simplemac\include; ..\..\..; ..\..\..\hal; ..\..\..\HAL\MICRO\CORTEXM3\STM32W108; ..\..\..\simplemac; ..\..\..\shared
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_MB851; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; PHY_STM32W108XX; DISABLE_WATCHDOG; __SOURCEFILE__="$FILE_FNAME$"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sample_sun.s37
  ILINK.IlinkOutputFile: sample_sun.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/stm32w108/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB851_PLANET (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_MB851; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board.h"; CORTEXM3; CORTEXM3_STM32W108; PHY_STM32W108XX; DISABLE_WATCHDOG; PLANET_ROLE; BOARD_MB851; __SOURCEFILE__="$FILE_FNAME$"
  OBJCOPY.OOCOutputFile: sample_planet.s37
  ILINK.IlinkOutputFile: sample_planet.out
configuration MB851_PLANET2 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: sample_planet.s37
  ILINK.IlinkOutputFile: sample_planet.out
configuration MB851_PLANET3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: sample_planet.s37
  ILINK.IlinkOutputFile: sample_planet.out
configuration MB851_PLANET1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: sample_planet.s37
  ILINK.IlinkOutputFile: sample_planet.out
  group hal
    ../../../hal/micro/cortexm3/: adc.c button.c clocks.c context-switch.s79 cstartup_M.s flash.c led.c mfg-token.c micro-common-internal.c micro-common.c micro.c nvm.c sleep.c spmr.s79 system-timer.c uart.c
    ../../../hal/micro/cortexm3/stm32w108/: low_level_init.c
  group sample_application
    ./: solar-system.c transmit.c
  group simplemac_library
    ../../library/: simplemac-library.a
